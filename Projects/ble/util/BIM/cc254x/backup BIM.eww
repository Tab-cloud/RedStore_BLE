<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>F:\BaiduNetdiskDownload\AmoMcu-CC254x&#x5F00;&#x53D1;&#x5957;&#x4eF6;&#x8D44;&#x6599;-2017.02\&#x4F8B;&#x7A0B;&#x8D44;&#x6599;\1.&#x57FA;&#x7840;&#x4F8B;&#x7A0B;-20171209&#x66F4;&#x65B0;\1.&#x57FA;&#x7840;&#x4F8B;&#x7A0B;\11.OLED&#x663e;&#x793A;&#x5C4F;\Test-IAR8.10\Test.ewp</path>
  </project>
  <batchBuild/>
</workspace>


